/*******************************************************************************
* (C) Copyright 2020;  WDB Systems India Pvt Ltd, Bangalore
* The attached material and the information contained therein is proprietary
* to WDB Systems India Pvt Ltd and is issued only under strict confidentiality
* arrangements.It shall not be used, reproduced, copied in whole or in part,
* adapted,modified, or disseminated without a written license of WDB Systems 
* India Pvt Ltd.It must be returned to WDB Systems India Pvt Ltd upon its first
* request.
*
*  File Name           : test_sensor.c
*
*  Description         : It contains rtc driver functions
*
*  Change history      : 
*
*     Author        Date           Ver                 Description
*  ------------    --------        ---   --------------------------------------
*   venu kosuri  16th Oct 2020     1.1               Initial Creation
*  
*******************************************************************************/

/*******************************************************************************
*                          Include Files
*******************************************************************************/
#include "sensor.h"
#include "trace.h"

/*******************************************************************************
*                          Extern Data Declarations
*******************************************************************************/

/*******************************************************************************
*                          Extern Function Declarations
*******************************************************************************/

/*******************************************************************************
*                          Type & Macro Definitions
*******************************************************************************/

/*******************************************************************************
*                          Static Function Prototypes
*******************************************************************************/

/*******************************************************************************
*                          Static Data Definitions
*******************************************************************************/

/*******************************************************************************
*                          Extern Data Definitions
*******************************************************************************/

/*******************************************************************************
*                          Extern Function Definitions
*******************************************************************************/

/*******************************************************************************
* Name       : 
* Description: 
* Remarks    : 
*******************************************************************************/
void SENSOR_Init()
{
}

/*******************************************************************************
* Name       : 
* Description: 
* Remarks    : 
*******************************************************************************/
FLOAT SENSOR_Get(U32 sensor_index , SENSOR_TYPE name)
{
    FLOAT value ;

    static U8 i = 0;

    TRACE_INFO("%s Entry \n", __FUNCTION__);

    switch ( name)
    {
        case SENSOR_TEMPERATURE:
            if( i == 1)
                value = 35;
            else
                value = 25;
            break;

        case SENSOR_HUMIDITY:
            if( i == 1)
                value = 70;
            else
                value = 60;
            break;
            
        case SENSOR_CO2:
            if( i == 1)
                value = 1300;
            else
                value = 1000;
            break;
    }

    if( i == 1)
    {
        i=0;
    }
    else
    	i++;

    TRACE_INFO("%s Exit = %.2f \n", __FUNCTION__, value);
    return value;


}

/*******************************************************************************
*                         Static Function Definitions
*******************************************************************************/

/*******************************************************************************
* Name       : 
* Description: 
* Remarks    : 
*******************************************************************************/


/*******************************************************************************
*                          End of File
*******************************************************************************/
